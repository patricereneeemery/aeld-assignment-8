DESCRIPTION = "AESD Image with Character Driver"
LICENSE = "CLOSED"

IMAGE_INSTALL += "aesd-char-driver"
inherit core-image
